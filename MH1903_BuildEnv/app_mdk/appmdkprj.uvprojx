# Keil uVision project appmdkprj.uvprojx, settings and files
target APP (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: appmdkprj +hex
  BeforeCompile: .\before_complie.bat
  AfterMake: fromelf.exe --bin .\Objects\appmdkprj.axf --output=.\app.bin
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,ARM_MATH_CM3
  c misc: --enum_is_int
  c include: ..\..\BaseApp\inc\core;..\..\BaseApp\inc\app;..\..\BaseApp\src\test
  memory RVCT4: ROM 0x1078000 size 0x30000
  memory RVCT9: RAM 0x20fc0000 size 0x4000
  scatter file: .\s1app.sct
  group startup
    ../src/startup/: startup_mhscpu.s
  group BaseApp
    ../../BaseApp/src/: common.c dlist.c main.c model_audio.c model_device.c model_key.c model_machine.c model_printer.c model_usbcdc.c model_wifi.c model_wireless.c parse_data.c postmessage.c queue.c tcp.c network_control_strategy.c event.c usbcdc_download.c machine_error.c device_config.c process_trenbtcmd.c model_tms.c http_download.c model_printport.c tms_schedule.c tms_common.c tms_download.c tms_upload.c
    ../../BaseApp/src/test/: single_test.c test_audio.c test_flash.c test_gprs.c test_key.c test_led.c test_printer.c test_wifi.c
